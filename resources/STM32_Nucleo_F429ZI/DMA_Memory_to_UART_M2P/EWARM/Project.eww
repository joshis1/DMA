<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DMA_Memory_to_UART_M2P.ewp</path>
  </project>
  <batchBuild />
</workspace>
